options:
  parameters:
    generate_options: qt_gui
    id: iiotest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/jiangrd3/code/lora_test/save_test
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("NEXT")
    period: '100'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
    vlen: 8192*2
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import zmq,time
      textboxValue = ""

      class my_sync_block(gr.sync_block):
          """
          reads input from a message port
          outputs text
          """
          def __init__(self,delay=10):
              gr.sync_block.__init__(self,
                  name = "LoRa Source",
                  in_sig = None,
                  out_sig = [np.complex64],
                  )
              file_name = '/home/jiangrd3/code/lora_test/dataset/'
              self.set_output_multiple(8192)
              self.label_t = np.load(file_name+'label.npy')
              self.data_t = np.load(file_name+'data.npy')
              a, self.b =  self.data_t.shape
              print('Opened')
              self.delay = delay
              self.count = 0
              self.max = self.label_t.shape[1]
              print("label shape:", self.label_t.shape, "max:", self.max)
              # 初始化ZMQ
              self.context = zmq.Context()

              self.last_send_time = time.time()
              self.ready_to_read = False
              self.reread = False
              self.replay = 0
              self.message_port_register_in(pmt.intern("trigger"))
              self.set_msg_handler(pmt.intern("trigger"), self.handle_trigger)

          def work(self, input_items, output_items):
              if time.time()-self.last_send_time>self.delay:

                  print(f"{time.time()-self.last_send_time} s since last send")
                  if self.count is None or self.max is None:
                      print("[ERROR] self.count or self.max is None!")
                      return -1
                  if self.reread:
                      self.reread = False
                      samples = self.data_t[self.count, :self.b//2]+1j*self.data_t[self.count, self.b//2:]

                      output_items[0][:8192] = samples[:8192]
                      self.ready_to_read = False
                      self.last_send_time = time.time()
                      print(f'Replay wave: {self.replay}')
                      self.replay += 1
                      # print(f"已发送一个波形，长度: {len(samples)} 个样本")
                      return 8192
                  if self.count >= self.max:
                      print("已到达文件末尾")
                      return -1
                  
                  # 转换数据并输出
                  if self.ready_to_read:
                      samples = self.data_t[self.count, :self.b//2]+1j*self.data_t[self.count, self.b//2:]
                      #for x in range(8192):
                      #    output_items[0][x] = samples[x]
                      output_items[0][:8192] = samples[:8192]
                      #output_items[0][:8192] = np.array(samples)
                      self.ready_to_read = False
                      self.reread = False
                      # print(f"已发送一个波形，长度: {len(samples)} 个样本")
                      self.count = self.count+1
                      self.replay = 0
                      self.last_send_time = time.time()
                      print(f'Next wave: {self.count}')
                      return 8192
              else:
                  output_items[0][:8192] = np.zeros(8192, dtype=np.complex64)
                  # self.last_send_time = time.time()
                  return 8192

          def stop(self):
              if hasattr(self, 'file') and self.file:
                  self.file.close()
              if hasattr(self, 'socket'):
                  self.socket.close()
              if hasattr(self, 'context'):
                  self.context.term()
              return True
          
          def handle_trigger(self, msg):
              msg = pmt.symbol_to_string(msg)
              if msg == "NEXT":
                  # print(msg)
                  self.ready_to_read = True
                  self.reread = False
                  # print("收到消息端口触发信号，准备读取下一个波形")
              if msg == "REPLAY":
                  # print(msg)
                  self.reread = True
                  self.ready_to_read = False
    delay: '0.3'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "# \"\"\"\n# Embedded Python Blocks:\n\n# Each time this file is saved, GRC will instantiate the first class it finds\n# to get ports and parameters of your block. The arguments to __init__  will\n# be the parameters. All of them are required to have default values!\n# \"\"\"\n\n# import numpy as np\n# from gnuradio import gr\n# import pmt\n# import time\n\n# class blk(gr.sync_block):\n#     \"\"\"LoRa Preamble Detector - Energy Detection Only\"\"\"\n\n#     def __init__(self, sample_rate=1e6, bandwidth=125e3, sf=7, threshold=0.2):\n#         gr.sync_block.__init__(\n#             self,\n#             name='LoRa Preamble Detector (Energy Only)',\n#             in_sig=[np.complex64],\n#             out_sig=[np.complex64]\n#         )\n#         self.sample_rate = sample_rate\n#         self.bandwidth = bandwidth\n#         self.sf = sf\n#         self.threshold = threshold\n        \n#         # 能量检测参数\n#         self.window_size = 128  # 能量计算窗口\n#         self.min_high_len = 256  # 最小高能量持续时间\n#         self.capture_len = 8192  # 捕获长度\n#         self.energy_threshold_factor = 5  # 能量阈值倍数\n        \n#         # 状态变量\n#         self.last_trigger_time = 0\n#         self.trigger_interval = 0.1  # 最小触发间隔(秒)\n#         self.detection_count = 0\n        \n#         # 设置输出多倍数\n#         self.set_output_multiple(self.capture_len*2)\n        \n#         # 注册消息输出端口\n#         self.message_port_register_out(pmt.intern(\"trigger\"))\n        \n#         print(\"LoRa能量检测器初始化完成\")\n\n#     def work(self, input_items, output_items):\n#         in0 = input_items[0]\n#         out = output_items[0]\n#         n_input = len(in0)\n#         # output_items[0][:] = in0\n#         # 透传数据\n#         out[:n_input] = in0\n        \n#         # 如果输入数据太少，直接返回\n#         if n_input < self.window_size + self.min_high_len:\n#             return n_input\n\n#         # 1. 计算滑动能量\n#         energy = np.convolve(np.abs(in0)**2, np.ones(self.window_size), 'valid') / self.window_size\n        \n#         # 2. 估计噪声基底（使用中位数更鲁棒）\n#         noise_floor = np.median(energy)\n#         threshold = noise_floor * self.energy_threshold_factor\n        \n#         # 3. 检测能量超过阈值的区域\n#         above_threshold = energy > threshold\n        \n#         # 4. 寻找连续的高能量区域\n#         # 使用差分找到上升沿和下降沿\n#         diff_above = np.diff(above_threshold.astype(int))\n#         rise_edges = np.where(diff_above == 1)[0]  # 上升沿\n#         fall_edges = np.where(diff_above == -1)[0]  # 下降沿\n        \n#         # 处理边界情况\n#         if len(rise_edges) > len(fall_edges):\n#             fall_edges = np.append(fall_edges, len(above_threshold) - 1)\n        \n#         # 5. 检查每个高能量区域\n#         for i in range(len(rise_edges)):\n#             start_idx = rise_edges[i]\n#             end_idx = fall_edges[i] if i < len(fall_edges) else len(above_threshold) - 1\n            \n#             # 检查持续时间是否足够长\n#             duration = end_idx - start_idx\n#             if duration >= self.min_high_len:\n#                 # 检查触发间隔\n#                 current_time = time.time()\n#                 if current_time - self.last_trigger_time > self.trigger_interval:\n#                     # 确保有足够的数据进行捕获\n#                     if start_idx + self.capture_len <= n_input:\n#                         # 发送触发消息\n#                         self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"NEXT\"))\n#                         self.last_trigger_time = current_time\n#                         self.detection_count += 1\n                        \n#                         print(f\"检测到信号 #{self.detection_count}, 能量: {np.mean(energy[start_idx:end_idx]):.2f}, 噪声基底: {noise_floor:.2f}\")\n                        \n#                         # 返回已处理的数据量\n#                         return n_input\n#                     else:\n#                         # 数据不足，等待更多数据\n#                         print(\"1\")\n#                 else:\n#                     print(\"2\")\n#             else:\n#                 print(\"3\")\n#         self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"REPLAY\"))            \n        \n#         return n_input\n\n#     #     output_items[0][:] = 0\n#     #     current_time = time.time()\n#     #     threshold = self.threshold\n#     #     step = max(1, self.symbol_length // 32)\n#     #     correlations = []\n#     #     positions = []\n#     #     for i in range(0, n_input - self.symbol_length, step):\n#     #         window = input_items[0][i:i+self.symbol_length]\n#     #         corr = np.abs(np.correlate(window, self.preamble_template, mode='valid'))[0]\n#     #         corr /= (np.linalg.norm(window) * np.linalg.norm(self.preamble_template) + 1e-10)\n#     #         correlations.append(corr)\n#     #         positions.append(i)\n#     #     found = False\n#     #     # print(f\"Correlation values: {correlations}\")  # Debug: print correlation values\n#     #     for idx in range(len(correlations) - 6):\n#     #         if all(c > threshold for c in correlations[idx:idx+7]):\n#     #             detection_index = positions[idx]\n#     #             detection_index = max(0, detection_index - self.symbol_length // 2)\n#     #             # print(f\"检测到连续7个前导峰，定位点: {detection_index}\")\n\n#     #             start_idx = detection_index\n#     #             end_idx = min(detection_index + self.preamble_length, n_input)\n#     #             if end_idx - start_idx >= self.preamble_length:\n#     #                 self.detected_preamble = input_items[0][start_idx:start_idx+self.preamble_length].copy()\n#     #                 output_len = min(n_output, len(self.detected_preamble))\n#     #                 output_items[0][:output_len] = self.detected_preamble[:output_len]\n#     #                 self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"NEXT\"))\n#     #                 self.detection_time = current_time\n#     #                 # print(f\"已提取前导样本点，长度: {len(self.detected_preamble)}\")\n#     #                 found = True\n#     #                 return output_len\n#     #             else:\n#     #                 self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"REPLAY\"))\n#     #                 # print(\"Need replay1\")\n#     #                 found = False\n#     #                 return n_input\n#     #     # if not found:\n#     #     #     # print(\"not find\")\n#     #     #     self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"REPLAY\"))\n#     #     #     return 0\n#     #     return n_input\n\n#     # def stop(self):\n#     #     return True\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport matplotlib.pyplot as plt\n\nclass LoRaPreambleDetector(gr.sync_block):\n    \"\"\"\n    LoRa 前导检测器（缓冲 + 分段能量检测）\n    \"\"\"\n    def __init__(self, sample_rate=1e6, bandwidth=125e3,\n                 sf=7, preamble_symbols=8,\n                 energy_window=128, energy_threshold_factor=0.5,\n                 step_size=256):\n        gr.sync_block.__init__(\n            self,\n            name=\"LoRa Preamble Detector\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        # LoRa 参数\n        self.sample_rate = sample_rate\n        self.bandwidth = bandwidth\n        self.sf = sf\n        self.symbol_len = int(2**sf * sample_rate / bandwidth)\n        self.preamble_len = preamble_symbols * self.symbol_len\n\n        # 能量检测参数\n        self.energy_window = energy_window\n        self.energy_threshold_factor = energy_threshold_factor\n        \n        self.step_size = step_size\n\n        # 输出长度控制\n        self.set_output_multiple(4096*2*2)  # 每次处理长度，保证work快\n\n        # 缓冲区\n        self.buffer = np.zeros(0, dtype=np.complex64)\n\n        # 消息端口\n        self.message_port_register_out(pmt.intern(\"trigger\"))\n\n        print(f\"LoRaPreambleDetector 初始化完成\")\n        print(f\"符号长度: {self.symbol_len}, 前导长度: {self.preamble_len}\")\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        # 1. 累积数据到缓存\n        self.buffer = np.concatenate([self.buffer, in0])\n        consumed = len(in0)   # 输入都要消费掉\n\n        # 2. 如果缓存不够，就先返回\n        if len(self.buffer) < self.preamble_len:\n            return consumed\n\n        # 3. 能量计算\n        segment = self.buffer\n        energy = np.convolve(np.abs(segment)**2, np.ones(self.energy_window), 'valid')\n        \n        noise_floor = np.mean(energy)   # 改成均值\n        threshold = max(noise_floor * self.energy_threshold_factor, 1e-3)\n        # print(threshold)\n        # 4. 上升沿检测\n        diff_energy = np.diff(energy)\n        rise_edges = np.where((diff_energy > 1e-3) & (energy[1:] > threshold))[0]\n\n        if len(rise_edges) > 0:\n            # np.save(f'{time.time()}.npy', energy)\n            start_idx = rise_edges[0]\n            if start_idx + self.preamble_len <= len(segment):\n                # print('dddddd')\n                preamble_segment = segment[start_idx:start_idx+self.preamble_len].copy()\n\n                # 输出 preamble\n                out_len = min(len(out), len(preamble_segment))\n                out[:out_len] = preamble_segment[:out_len]\n                print(len(preamble_segment))\n                # 发送触发消息\n                self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"NEXT\"))\n                # np.save(f'{time.time()}.npy', preamble_segment)\n                # 丢掉已处理数据\n                self.buffer = self.buffer[start_idx + self.preamble_len:]\n                return consumed\n\n        # 5. 如果没检测到，就保留 buffer，只消费输入\n        if len(self.buffer) > 10 * self.preamble_len:\n            # 防止无限堆积\n            self.buffer = self.buffer[-10 * self.preamble_len:]\n        self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"REPLAY\"))\n        return consumed\n\n"
    bandwidth: '125000.0'
    energy_threshold_factor: '1'
    energy_window: '128'
    preamble_symbols: '8'
    sample_rate: '1000000.0'
    sf: '7'
    step_size: '64'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import time
      import threading
      from gnuradio import gr
      import pmt

      class message_strobe(gr.basic_block):
          """
          Python实现的Message Strobe Block
          定时向消息端口发送字符串
          """
          def __init__(self, period=0.1, msg="REPLAY"):
              gr.basic_block.__init__(
                  self,
                  name="Python Message Strobe",
                  in_sig=None,
                  out_sig=None
              )
              self.period = period
              self.msg = msg
              self.message_port_register_out(pmt.intern("strobe"))
              self._stop_event = threading.Event()
              self._thread = threading.Thread(target=self._strobe_loop)
              self._thread.daemon = True
              self._thread.start()

          def _strobe_loop(self):
              while not self._stop_event.is_set():
                  self.message_port_pub(pmt.intern("strobe"), pmt.intern(self.msg))
                  time.sleep(self.period)

          def stop(self):
              self._stop_event.set()
              self._thread.join()
              return True
    msg: '"Next"'
    period: '1'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '30'
    freq0: 868e6
    gain0: '50'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 868e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"detect"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"sent"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"usrp in"'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 868e6
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 868e6
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, trigger]
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [epy_block_0, '0', osmosdr_sink_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0_0, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', qtgui_sink_x_0, '0']
- [epy_block_2, strobe, epy_block_0, trigger]
- [osmosdr_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
