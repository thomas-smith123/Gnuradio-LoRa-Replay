options:
  parameters:
    generate_options: qt_gui
    id: iiotest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/jiangrd3/code/lora_test/save_test
    type: complex
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("NEXT")
    period: '100'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
    vlen: 8192*2
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport zmq,time\ntextboxValue = \"\"\n\nclass my_sync_block(gr.sync_block):\n    \"\"\"\n    reads input from a message port\n    outputs text\n    \"\"\"\n    def __init__(self,delay=10):\n        gr.sync_block.__init__(self,\n            name = \"LoRa Source\",\n            in_sig = None,\n            out_sig = [np.complex64],\n            )\n        file_name = '/home/jiangrd3/code/lora_test/dataset/'\n        self.set_output_multiple(8192)\n        self.label_t = np.load(file_name+'label.npy')\n        self.data_t = np.load(file_name+'data.npy')\n        a, self.b =  self.data_t.shape\n        print('Opened')\n        self.delay = delay\n        self.count = 0\n        self.max = self.label_t.shape[1]\n        print(\"label shape:\", self.label_t.shape, \"max:\", self.max)\n        # 初始化ZMQ\n        self.context = zmq.Context()\n\n        self.last_send_time = time.time()\n        self.ready_to_read = False\n        self.reread = False\n        self.replay = 0\n        self.message_port_register_in(pmt.intern(\"trigger\"))\n        self.set_msg_handler(pmt.intern(\"trigger\"), self.handle_trigger)\n        self.trig_mark = False\n    def work(self, input_items, output_items):\n        if time.time()-self.last_send_time>self.delay:\n\n            print(f\"{time.time()-self.last_send_time} s since last send\")\n            if self.count is None or self.max is None:\n                print(\"[ERROR] self.count or self.max is None!\")\n                return -1\n            \n            # 转换数据并输出\n            if self.ready_to_read:\n                samples = self.data_t[self.count, :self.b//2]+1j*self.data_t[self.count, self.b//2:]\n                #for x in range(8192):\n                #    output_items[0][x] = samples[x]\n                output_items[0][:8192] = samples[:8192]\n                #output_items[0][:8192] = np.array(samples)\n                self.ready_to_read = False\n                self.reread = False\n                # print(f\"已发送一个波形，长度: {len(samples)} 个样本\")\n                self.count = self.count+1\n                self.replay = 0\n                self.last_send_time = time.time()\n                print(f'Next wave: {self.count}')\n                self.trig_mark = False\n                return 8192\n            \n            if self.reread:\n                self.reread = False\n                samples = self.data_t[self.count, :self.b//2]+1j*self.data_t[self.count, self.b//2:]\n\n                output_items[0][:8192] = samples[:8192]\n                self.ready_to_read = False\n                self.last_send_time = time.time()\n                print(f'Replay wave: {self.replay}')\n                self.replay += 1\n                # print(f\"已发送一个波形，长度: {len(samples)} 个样本\")\n                return 8192\n            \n            if self.count >= self.max:\n                print(\"已到达文件末尾\")\n                return -1\n        else:\n            output_items[0][:8192] = np.zeros(8192, dtype=np.complex64)\n            # self.last_send_time = time.time()\n            return 8192\n\n    def stop(self):\n        if hasattr(self, 'file') and self.file:\n            self.file.close()\n        if hasattr(self, 'socket'):\n            self.socket.close()\n        if hasattr(self, 'context'):\n            self.context.term()\n        return True\n    \n    def handle_trigger(self, msg):\n        if not self.trig_mark:\n            msg = pmt.symbol_to_string(msg)\n            if msg == \"NEXT\":\n                # print(msg)\n                self.ready_to_read = True\n                self.reread = False\n                self.trig_mark = True\n                # print(\"收到消息端口触发信号，准备读取下一个波形\")\n            if msg == \"REPLAY\":\n                # print(msg)\n                self.reread = True\n                self.ready_to_read = False\n            "
    delay: '0.3'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport matplotlib.pyplot as plt\n\nclass LoRaPreambleDetector(gr.sync_block):\n    \"\"\"\n    LoRa 前导检测器（缓冲 + 分段能量检测）\n    \"\"\"\n    def __init__(self, sample_rate=1e6, bandwidth=125e3,\n                 sf=7, preamble_symbols=8,\n                 energy_window=128, energy_threshold_factor=0.5,\n                 step_size=256,save_path='./'):\n        gr.sync_block.__init__(\n            self,\n            name=\"LoRa Preamble Detector\",\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        # LoRa 参数\n        self.sample_rate = sample_rate\n        self.bandwidth = bandwidth\n        self.sf = sf\n        self.symbol_len = int(2**sf * sample_rate / bandwidth)\n        self.preamble_len = preamble_symbols * self.symbol_len\n        self.save_path = save_path\n        # 能量检测参数\n        self.energy_window = energy_window\n        self.energy_threshold_factor = energy_threshold_factor\n        \n        self.step_size = step_size\n\n        # 输出长度控制\n        self.set_output_multiple(4096*5)  # 每次处理长度，保证work快\n\n        # 缓冲区\n        self.buffer = np.zeros(0, dtype=np.complex64)\n\n        # 消息端口\n        self.message_port_register_out(pmt.intern(\"trigger\"))\n\n        print(f\"LoRaPreambleDetector 初始化完成\")\n        print(f\"符号长度: {self.symbol_len}, 前导长度: {self.preamble_len}\")\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        # 1. 累积数据到缓存\n        self.buffer = np.concatenate([self.buffer, in0])\n        consumed = len(in0)   # 输入都要消费掉\n\n        # 2. 如果缓存不够，就先返回\n        if len(self.buffer) < self.preamble_len:\n            return consumed\n\n        # 3. 能量计算\n        segment = self.buffer\n        energy = np.convolve(np.abs(segment)**2, np.ones(self.energy_window), 'valid')\n        \n        noise_floor = np.mean(energy)   # 改成均值\n        threshold = max(noise_floor * self.energy_threshold_factor, 1e-3)\n        # print(threshold)\n        # 4. 上升沿检测\n        diff_energy = np.diff(energy)\n        rise_edges = np.where((diff_energy > 1e-3) & (energy[1:] > threshold))[0]\n\n        if len(rise_edges) > 0:\n            # np.save(f'{time.time()}.npy', energy)\n            start_idx = rise_edges[0]\n            if start_idx + self.preamble_len+self.energy_window//2 <= (len(segment)) :\n                # print('dddddd')\n                preamble_segment = segment[start_idx+ self.energy_window//2:start_idx+self.preamble_len+self.energy_window//2].copy()\n                # np.save(f'{time.time()}.npy', energy)\n                # 输出 preamble\n                out_len = min(len(out), len(preamble_segment))\n                out[:out_len] = preamble_segment[:out_len]\n                # print(len(preamble_segment))\n                # 发送触发消息\n                self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"NEXT\"))\n                np.save(self.save_path+f'{time.time()}.npy', preamble_segment)\n                # 丢掉已处理数据\n                self.buffer = self.buffer[start_idx + self.preamble_len:]\n                return consumed\n\n        # 5. 如果没检测到，就保留 buffer，只消费输入\n        if len(self.buffer) > 10 * self.preamble_len:\n            # 防止无限堆积\n            self.buffer = self.buffer[-10 * self.preamble_len:]\n            self.message_port_pub(pmt.intern(\"trigger\"), pmt.intern(\"REPLAY\"))\n        return consumed\n\n"
    bandwidth: '125000.0'
    energy_threshold_factor: '1'
    energy_window: '128'
    preamble_symbols: '8'
    sample_rate: '1000000.0'
    save_path: '''./'''
    sf: '7'
    step_size: '64'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import time
      import threading
      from gnuradio import gr
      import pmt

      class message_strobe(gr.basic_block):
          """
          Python实现的Message Strobe Block
          定时向消息端口发送字符串
          """
          def __init__(self, period=0.1, msg="REPLAY"):
              gr.basic_block.__init__(
                  self,
                  name="Python Message Strobe",
                  in_sig=None,
                  out_sig=None
              )
              self.period = period
              self.msg = msg
              self.message_port_register_out(pmt.intern("strobe"))
              self._stop_event = threading.Event()
              self._thread = threading.Thread(target=self._strobe_loop)
              self._thread.daemon = True
              self._thread.start()

          def _strobe_loop(self):
              while not self._stop_event.is_set():
                  self.message_port_pub(pmt.intern("strobe"), pmt.intern(self.msg))
                  time.sleep(self.period)

          def stop(self):
              self._stop_event.set()
              self._thread.join()
              return True
    msg: '"Next"'
    period: '1'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '30'
    freq0: 868e6
    gain0: '50'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 868e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"detect"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"sent"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    name: '"usrp in"'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 868e6
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 868e6
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, trigger]
- [blocks_stream_to_vector_0, '0', epy_block_1, '0']
- [epy_block_0, '0', osmosdr_sink_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0_0, '0']
- [epy_block_0, '0', uhd_usrp_sink_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', qtgui_sink_x_0, '0']
- [epy_block_1, trigger, epy_block_0, trigger]
- [epy_block_2, strobe, epy_block_0, trigger]
- [osmosdr_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
